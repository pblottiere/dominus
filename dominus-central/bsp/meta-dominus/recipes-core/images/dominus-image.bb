SUMMARY = "dominus image"
LICENSE = "CLOSED"

inherit core-image

IMAGE_FEATURES += "ssh-server-dropbear"
